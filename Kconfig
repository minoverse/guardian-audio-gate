## Kconfig
```kconfig
config GUARDIAN
    bool "Guardian Audio Gate"
    default n

source "Kconfig.zephyr"
```
